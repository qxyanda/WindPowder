# Keil uVision project templete.uvprojx, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK60D10, __FPU_PRESENT=1,__FPU_USED =1,__CC_ARM,ARM_MATH_CM4
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\utilities\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group user
    ../src/: main.c ini.c sw.c tc.c dcp.c
    ./: Data.c Read.c output.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c adc.c systick.c common.c i2c.c pit.c
    ../../../../Libraries/drivers/K/src/dsp/lib/: arm_cortexM4lf_math.lib
    ../../../../Libraries/devices/src/: at24cxx.c
    ../src/: crc.c
target mk64f12 (ARM-ADS)
  device: MK64FX512xxx12 NXP
  cpu: IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00020000) IRAM(0x20000000,0x00020000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK64F12 RAVEN DEBUG, __FPU_PRESENT=1,__FPU_USED =1,__CC_ARM,ARM_MATH_CM4
  c misc: --c99
  c include: ..\Libraries\startup\CoreSupport;..\Libraries\startup\DeviceSupport;..\Libraries\drivers\K\inc;..\Libraries\utilities\inc;..\Libraries\devices\inc;..\Libraries\utilities\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
